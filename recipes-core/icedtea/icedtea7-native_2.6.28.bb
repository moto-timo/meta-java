require icedtea7-native-2.6.28.inc

PR = "${INC_PR}.0"

ICEDTEA = "icedtea-${PV}"

SRC_URI[iced.sha256sum] = "b42fc48d530b513455112492b219f461793499978b1f9722f73a1a5dcac7ce11"

#HOTSPOT_CHANGESET = "a456d0771ba0"
#SRC_URI[hotspot.sha256sum] = "69719a9657b15e6bef1bef137a15d830293091fbc46616fe8759e863ba904442"

#CORBA_CHANGESET = "79ee8535bc51"
#SRC_URI[corba.sha256sum] = "00bf0b0996484db3d0497345ca5b14db4ffb2288b6c7adf8a003b2eafc396fb2"

#JAXP_CHANGESET = "77e7219c7424"
#SRC_URI[jaxp.sha256sum] = "bb4beb62fae52d0ff871aefd64ae54eaed8978bff87df1e23f1bfead40ceae6d"

#JAXWS_CHANGESET = "d92eda447bca"
#SRC_URI[jaxws.sha256sum] = "566778320a0fa18ca93427d6afadc8bd3e416fd8249f9ce88e37e215f9295335"

#JDK_CHANGESET = "d7ecb57d3c61"
#SRC_URI[jdk.sha256sum] = "b24bf93559804610a6e1078bea94adcec1b2f818dd600b12304926f6e86c6747"

#LANGTOOLS_CHANGESET = "fd2fdb20d858"
#SRC_URI[langtools.sha256sum] = "10fee41a0cdd1b166ff78e6426430c76af0f2358d026c181d325af1e41646c34"

#OPENJDK_CHANGESET = "f89009ada191"
#SRC_URI[openjdk.sha256sum] = "5efd8e66f18fcbf45527bcc74aa3e6ed11f66bc793c88e3841925c4acb4827ba"
