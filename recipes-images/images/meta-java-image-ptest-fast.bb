require meta-java-image-ptest-all.bb

DESCRIPTION = "Recipe to trigger execution of all fast meta-java ptest images."

PTESTS_META_JAVA = "${PTESTS_FAST_META_PYTHON}"

